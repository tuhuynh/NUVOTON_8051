# Keil uVision project test_gpio.uvproj, settings and files
target Target 1 (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: test_gpio
  c flags: Optimize=8 SizeSpeed=1
  c define: FOSC_160000
  c include: ..\Include
  group SRC
    ./: test_n76e003.c
  group COMMON
    ../Common/: Common.c Delay.c
  group STARTUP
    ./: STARTUP.A51
