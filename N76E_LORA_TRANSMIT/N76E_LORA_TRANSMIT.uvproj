# Keil uVision project N76E_LORA_TRANSMIT.uvproj, settings and files
target N76E_LORA_TRANSMIT (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: N76E_LORA_TRANSMIT
  c flags: Optimize=8 SizeSpeed=1
  c define: FOSC_160000
  c include: ..\Include
  group Code
    ./Code/: main.c
  group Common
    ../Common/: Common.c Delay.c
  group Startup
    ../Startup/: STARTUP.A51
